# Keil uVision project Balance_Bot.uvprojx, settings and files
target Balance_Bot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance_Bot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no_multibyte_chars
  c include: ..\User;..\APP;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_exti.c
  group USER
    ../User/: main.c stm32f1xx_it.c stm32f1xx_hal_conf.h pin_map.h printf_redirect.c stm32_init.c
    ../User/dwt/: bsp_dwt.c
    ../User/led/: bsp_led.c
    ../User/usart/: bsp_usart.c
    ../User/encoder/: bsp_encoder.c
    ../User/mpu6050/: bsp_mpu6050.c
    ../User/bluetooth/: bsp_bluetooth.c
  group APP
    ../APP/balance/: app_balance.c
    ../APP/motor/: app_motor.c
    ../APP/pid/: app_pid.c
